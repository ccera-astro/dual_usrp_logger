options:
  parameters:
    generate_options: no_gui
    id: dual_usrp_logger
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: dyn_freq
  id: variable
  parameters:
    value: flist[int(time.time()) % 2]+(0.0*pacer)
  states: {}
- name: fftsize
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: flist
  id: variable
  parameters:
    value: '[freq1,freq2]'
  states: {}
- name: pacer
  id: variable_function_probe
  parameters:
    block_id: pacer_probe
    function_name: level
    poll_rate: '1.0'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(srate)
  states: {}
- name: tr
  id: variable
  parameters:
    value: uhd.tune_request(dyn_freq,samp_rate/2.0)
  states: {}
- name: winpower
  id: variable
  parameters:
    value: sum([x*x for x in window.blackman_harris(fftsize)])
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: seconds*samp_rate
    type: complex
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: seconds*samp_rate
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/fftsize/20)
    type: float
    vlen: fftsize
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/fftsize/20)
    type: float
    vlen: fftsize
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '-20*math.log10(fftsize)-10*math.log10(winpower/fftsize)'
    n: '10'
    vlen: fftsize
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '-20*math.log10(fftsize)-10*math.log10(winpower/fftsize)'
    n: '10'
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: device
  id: parameter
  parameters:
    label: Device spec
    type: str
    value: '"type=b200,otw_format=sc8,num_recv_frames=512"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: freq1
  id: parameter
  parameters:
    label: RF Frequency 1
    type: eng_float
    value: 1413.5e6
  states: {}
- name: freq2
  id: parameter
  parameters:
    label: RF Frequency 2
    type: eng_float
    value: 525e6
  states: {}
- name: gain
  id: parameter
  parameters:
    label: RF Gain
    type: eng_float
    value: '60'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: logger_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import ephem
      import math


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fftsize=2048,prefix="./",longitude=-76.03,logtime=10, frequency=1420.4058e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='FFT logger block',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)]*2,
                  out_sig=None

              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fftsize = fftsize
              self.prefix=prefix
              self.last = time.time()
              self.longitude = longitude
              self.logtime = logtime
              self.frequency = frequency
              self.myffts = {}
              self.mycounts = {}
              self.current = self.frequency
              self.set_output_multiple(2)


          # Given longitude(decimal degrees as a float)
          #
          # Return the current sidereal time as a string with
          #  "," separated tokens
          #
          def cur_sidereal(self,longitude):
              longstr = "%02d" % int(longitude)
              longstr = longstr + ":"
              longitude = abs(longitude)
              frac = longitude - int(longitude)
              frac *= 60
              mins = int(frac)
              longstr += "%02d" % mins
              longstr += ":00"
              x = ephem.Observer()
              x.date = ephem.now()
              x.long = longstr
              jdate = ephem.julian_date(x)
              tokens=str(x.sidereal_time()).split(":")
              hours=int(tokens[0])
              minutes=int(tokens[1])
              seconds=int(float(tokens[2]))
              sidt = "%02d,%02d,%02d" % (hours, minutes, seconds)
              return (sidt)
              
          def do_the_log(self, fn, tp, val, cf):
              fp = open(fn, "a")
              fp.write("%02d,%02d,%02d," % (tp.tm_hour, tp.tm_min, tp.tm_sec))
              lmst = self.cur_sidereal(self.longitude)
              fp.write("%s," % lmst)
              fp.write("%d," % cf)
              for i in range(len(val)):
                  fp.write("%7.3f" % val[i])
                  if (i < (len(val)-1)):
                      fp.write(",")
              fp.write("\n")
              fp.close()

          def work(self, input_items, output_items):
              """Accumulate and log FFT buffers"""
              
              #
              # Used to skip first buffer after frequency-switch
              #
              skip = False
              
              #
              # If we've just switched frequency, discard input for one
              #  cycle
              #
              if (self.current != self.frequency):
                  self.current = self.frequency
                  skip = True

              curf = int(self.frequency/1.0e6)
              
              #
              # Is a new frequency?  Initialize averaging buffers
              #
              if (curf not in self.myffts):
                  self.myffts[curf] = [np.zeros(self.fftsize,dtype=np.float32),
                      np.zeros(self.fftsize,dtype=np.float32)]
                  self.mycounts[curf] = [0,0]
              
              if (skip == True):
                  s = 1
              else:
                  s = 0
                  
              for v in input_items[0]:
                  if (s <= 0):
                      self.myffts[curf][0] = np.add(v,self.myffts[curf][0])
                      self.mycounts[curf][0] += 1
                  else:
                      s -= 1
               
              if (skip == True):
                  s = 1
              else:
                  s = 0
               
              for v in input_items[1]:
                  if (s <= 0):
                      self.myffts[curf][1] = np.add(v,self.myffts[curf][1])
                      self.mycounts[curf][1] += 1
                  else:
                      s -= 1
              
              #
              #
              #
              if ((time.time() - self.last) > self.logtime):
                  for ndx in self.myffts:
                      lva = np.divide(self.myffts[ndx][0],self.mycounts[ndx][0])
                      lvb = np.divide(self.myffts[ndx][1],self.mycounts[ndx][1])
                      
                      #
                      # Counters
                      #
                      self.mycounts[ndx][0] = 0
                      self.mycounts[ndx][1] = 0
                      
                      #
                      # Averaging buffers
                      #
                      self.myffts[ndx][0] = np.zeros(self.fftsize,dtype=np.float32)
                      self.myffts[ndx][1] = np.zeros(self.fftsize,dtype=np.float32)
                      
                      
                      #
                      # Form filenames
                      #
                      fn_a = self.prefix + "fft-A-%d-" % ndx
                      ltp = time.gmtime()
                      fn_a += "%04d%02d%02d.csv" % (ltp.tm_year, ltp.tm_mon,
                          ltp.tm_mday)
                      fn_b = self.prefix + "fft-B-%d-" % ndx
                      fn_b += "%04d%02d%02d.csv" % (ltp.tm_year, ltp.tm_mon,
                          ltp.tm_mday)
                      
                      #
                      # Log the data
                      #
                      self.do_the_log(fn_a, ltp, lva, ndx)
                      self.do_the_log(fn_b, ltp, lvb, ndx)
                  self.last = time.time()
                  
              return len(input_items[0])
    fftsize: '2048'
    frequency: dyn_freq
    logtime: logtime
    longitude: longitude
    prefix: prefix
  states: {}
- name: logtime
  id: parameter
  parameters:
    label: Logging time
    type: intx
    value: '15'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: Local longitude
    type: eng_float
    value: '-76.03'
  states: {}
- name: pacer_probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: File prefix
    type: str
    value: '"./"'
  states: {}
- name: seconds
  id: parameter
  parameters:
    label: Seconds runtime
    type: eng_float
    value: '600'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/((samp_rate/fftsize)/20)
    type: float
    vlen: fftsize
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/((samp_rate/fftsize)/20)
    type: float
    vlen: fftsize
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: 27e6
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    bw0: samp_rate*0.8
    bw1: samp_rate*0.8
    center_freq0: dyn_freq
    center_freq1: dyn_freq
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: device
    dev_args: '""'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: samp_rate
    sd_spec0: A:A A:B
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_complex_to_real_0, '0', pacer_probe, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_head_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_nlog10_ff_0, '0', logger_0, '0']
- [blocks_nlog10_ff_0_0, '0', logger_0, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '1', blocks_complex_to_real_0, '0']
- [uhd_usrp_source_0, '1', blocks_head_0_0, '0']

metadata:
  file_format: 1
